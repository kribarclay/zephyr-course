## app/Kconfig
```kconfig
config APP_HEARTBEAT_PERIOD_MS
    int "LED heartbeat period (ms)"
    default 500
    range 100 2000

source "Kconfig.zephyr"
```
